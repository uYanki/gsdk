# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-shift-negative-value -Wno-shift-count-negative -Wno-int-to-void-pointer-cast -Wno-unused-value
  c include: ../Core/Inc;../../../kernel;../../../kernel/hwif;../../../components/device;../../../components/flexbtn;../../../components/motspin/fixed-point;../../../components/shell1;../../../platform/stm32f4_hal/boards/stm32f407ve_xws;../../../platform/stm32f4_hal/adapter;../../../components/CmBacktrace;../../../components/EmberGL;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: demo_EmberGL.c app_EmberGL.cpp main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group kernel/hwif
    ../../../kernel/hwif/: delay.c pinctrl.c i2cmst.c spimst.c swi2cmst.c swspimst.c
  group kernel/base
    ../../../kernel/: gversion.c hexdump.c logger.c gstdio.c bitops.c
  group platform/adapter
    ../../../platform/stm32f4_hal/adapter/: arm_dwt.c arm_swo.c drv_hwi2cmst.c drv_hwspimst.c drv_hwuart.c drv_pinctrl.c drv_timer.c syscall.c
  group components/flexbtn
    ../../../components/flexbtn/: flexbtn.c flexbtn_demo.c
  group components/segger-rtt
    ../../../components/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group components/cmbacktrace
    ../../../components/CmBacktrace/: cm_backtrace.c cmb_fault_keil.S
  group components/device
    ../../../components/device/: spi_st7735.c
  group components/EmberGL
    ../../../components/EmberGL/: egl_core.cpp egl_mesh.cpp egl_rasterizer.cpp egl_rasterizer_cache.cpp egl_rasterizer_tiling.cpp egl_texture.cpp
    ../../../components/EmberGL/drivers/: egl_device_st7735.cpp
software components: CMSIS:CORE 6.0.0
