# Keil uVision project demo.uvprojx, settings and files
target STM32F103C8T6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS-DAP +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, BOARD_V3
  c include: Drivers\CMSIS\CoreSupport;Drivers\DFP\2.1.0\Include;Drivers\DFP\2.1.0\Peripherals\inc;.\Core\usb\inc;.\Core\dap;.\Core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Peripherals
    Drivers/DFP/2.1.0/Peripherals/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_rcc.c misc.c
  group USB
    ./Core/usb/src/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group DAP
    ./Core/dap/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
  group Src
    ./Core/: system_stm32f10x.c CMSIS-DAP.c usb_config.c usbd_STM32F103.c usbd_user_hid.c UserApp.c startup_stm32f10x_md.s
