# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,LV_LVGL_H_INCLUDE_SIMPLE
  c misc: -Wno-shift-negative-value -Wno-shift-count-negative -Wno-int-to-void-pointer-cast -Wno-unused-value
  c include: ../Core/Inc;../../../kernel;../../../kernel/hwif;../../../components/device;../../../components/flexbtn;../../../platform/stm32f4_hal/boards/stm32f407ve_xws;../../../platform/stm32f4_hal/adapter;../../../components/CmBacktrace;../../../components/LVGL9;../LVGL;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: lvgl_demo.c main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group kernel/hwif
    ../../../kernel/hwif/: delay.c pinctrl.c i2cmst.c spimst.c swi2cmst.c swspimst.c
  group kernel/base
    ../../../kernel/: gversion.c hexdump.c logger.c gstdio.c bitops.c
  group platform/adapter
    ../../../platform/stm32f4_hal/adapter/: arm_dwt.c arm_swo.c drv_hwi2cmst.c drv_hwspimst.c drv_hwuart.c drv_pinctrl.c drv_timer.c syscall.c
  group components/segger-rtt
    ../../../components/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group components/cmbacktrace
    ../../../components/CmBacktrace/: cm_backtrace.c cmb_fault_keil.S
  group components/device
    ../../../components/device/: spi_st7735.c
  group lvgl/core
    ../../../components/LVGL9/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/draw
    ../../../components/LVGL9/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../components/LVGL9/src/draw/nxp/pxp/: lv_draw_pxp_blend.c
    ../../../components/LVGL9/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c
    ../../../components/LVGL9/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../../components/LVGL9/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../../components/LVGL9/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/hal
    ../../../components/LVGL9/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/layout
    ../../../components/LVGL9/src/layouts/flex/: lv_flex.c
    ../../../components/LVGL9/src/layouts/grid/: lv_grid.c
  group lvgl/widgets
    ../../../components/LVGL9/src/widgets/animimg/: lv_animimg.c
    ../../../components/LVGL9/src/widgets/arc/: lv_arc.c
    ../../../components/LVGL9/src/widgets/bar/: lv_bar.c
    ../../../components/LVGL9/src/widgets/btn/: lv_btn.c
    ../../../components/LVGL9/src/widgets/btnmatrix/: lv_btnmatrix.c
    ../../../components/LVGL9/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../components/LVGL9/src/widgets/canvas/: lv_canvas.c
    ../../../components/LVGL9/src/widgets/chart/: lv_chart.c
    ../../../components/LVGL9/src/widgets/checkbox/: lv_checkbox.c
    ../../../components/LVGL9/src/widgets/colorwheel/: lv_colorwheel.c
    ../../../components/LVGL9/src/widgets/dropdown/: lv_dropdown.c
    ../../../components/LVGL9/src/widgets/img/: lv_img.c
    ../../../components/LVGL9/src/widgets/imgbtn/: lv_imgbtn.c
    ../../../components/LVGL9/src/widgets/keyboard/: lv_keyboard.c
    ../../../components/LVGL9/src/widgets/label/: lv_label.c
    ../../../components/LVGL9/src/widgets/led/: lv_led.c
    ../../../components/LVGL9/src/widgets/line/: lv_line.c
    ../../../components/LVGL9/src/widgets/list/: lv_list.c
    ../../../components/LVGL9/src/widgets/menu/: lv_menu.c
    ../../../components/LVGL9/src/widgets/meter/: lv_meter.c
    ../../../components/LVGL9/src/widgets/msgbox/: lv_msgbox.c
    ../../../components/LVGL9/src/widgets/objx_templ/: lv_objx_templ.c
    ../../../components/LVGL9/src/widgets/roller/: lv_roller.c
    ../../../components/LVGL9/src/widgets/slider/: lv_slider.c
    ../../../components/LVGL9/src/widgets/span/: lv_span.c
    ../../../components/LVGL9/src/widgets/spinbox/: lv_spinbox.c
    ../../../components/LVGL9/src/widgets/spinner/: lv_spinner.c
    ../../../components/LVGL9/src/widgets/switch/: lv_switch.c
    ../../../components/LVGL9/src/widgets/table/: lv_table.c
    ../../../components/LVGL9/src/widgets/tabview/: lv_tabview.c
    ../../../components/LVGL9/src/widgets/textarea/: lv_textarea.c
    ../../../components/LVGL9/src/widgets/tileview/: lv_tileview.c
    ../../../components/LVGL9/src/widgets/win/: lv_win.c
  group lvgl/misc
    ../../../components/LVGL9/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_malloc_builtin.c lv_math.c lv_mem.c lv_memcpy_builtin.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/other
    ../../../components/LVGL9/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../components/LVGL9/src/others/gridnav/: lv_gridnav.c
    ../../../components/LVGL9/src/others/ime/: lv_ime_pinyin.c
    ../../../components/LVGL9/src/others/imgfont/: lv_imgfont.c
    ../../../components/LVGL9/src/others/monkey/: lv_monkey.c
    ../../../components/LVGL9/src/others/msg/: lv_msg.c
  group lvgl/theme
    ../../../components/LVGL9/src/others/snapshot/: lv_snapshot.c
    ../../../components/LVGL9/src/themes/basic/: lv_theme_basic.c
    ../../../components/LVGL9/src/themes/default/: lv_theme_default.c
    ../../../components/LVGL9/src/themes/mono/: lv_theme_mono.c
  group lvgl/port
    ../LVGL/: lv_conf.h
    ../LVGL/porting/: lv_port_disp.c lv_port_indev.c lv_port_fs.c
  group lvgl/font
    ../../../components/LVGL9/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group lvgl/demo
    ../LVGL/demos/benchmark/: lv_demo_benchmark.c
    ../LVGL/demos/benchmark/assets/: lv_font_bechmark_montserrat_28_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_12_compr_az.c.c img_benchmark_cogwheel_rgb565a8.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_alpha16.c
  group Drivers/STM32F4xx_HAL_Driver
    F:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 6.0.0
