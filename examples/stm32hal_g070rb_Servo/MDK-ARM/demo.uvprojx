# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,STM32G070xx
  c misc: -Wno-shift-negative-value -Wno-shift-count-negative -Wno-int-to-void-pointer-cast -Wno-unused-value
  c include: ../Core/Inc;../../../kernel;../../../kernel/hwif;../../../components/device;../../../components/flexbtn;../../../components/motspin/fixed-point;../../../platform/stm32g0_hal/board/stm32g070rb_umotion;../../../platform/stm32g0_hal/adapter;../../../components/CmBacktrace;F:/gsdk/platform/stm32g0_hal/fwlib/STM32Cube_FW_G0_V1.6.0/Drivers/STM32G0xx_HAL_Driver/Inc;F:/gsdk/platform/stm32g0_hal/fwlib/STM32Cube_FW_G0_V1.6.0/Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;F:/gsdk/platform/stm32g0_hal/fwlib/STM32Cube_FW_G0_V1.6.0/Drivers/CMSIS/Device/ST/STM32G0xx/Include;F:/gsdk/platform/stm32g0_hal/fwlib/STM32Cube_FW_G0_V1.6.0/Drivers/CMSIS/Include;../Libraries;../Database;../Bsp;..\..\..\platform\stm32g0_hal\fwlib\STM32Cube_FW_G0_V1.6.0\Drivers\CMSIS\DSP\Include;..\Axis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Application/MDK-ARM
    ./: startup_stm32g070xx.s
  group Application/User/Core
    ../Core/Inc/: gconf.h
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c i2c.c spi.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    F:/gsdk/platform/stm32g0_hal/fwlib/STM32Cube_FW_G0_V1.6.0/Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group kernel/hwif
    ../../../kernel/hwif/: delay.c pinctrl.c i2cmst.c spimst.c swi2cmst.c swspimst.c
  group kernel/base
    ../../../kernel/: gversion.c hexdump.c logger.c gstdio.c bitops.c
  group platform/adapter
    ../../../platform/stm32g0_hal/adapter/: drv_hwi2cmst.c drv_hwspimst.c drv_hwuart.c drv_pinctrl.c drv_timer.c swrst.c syscall.c
  group components/device
    ../../../components/device/: i2c_eeprom.c i2c_ssd1306.c mono_framebuf.c mono_font.c spi_mt6701.c
  group components/flexbtn
    ../../../components/flexbtn/: flexbtn.c flexbtn_demo.c
  group components/segger-rtt
    ../../../components/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group components/cmbacktrace
    ../../../components/CmBacktrace/: cm_backtrace.c cmb_fault_keil.S
  group encoder/tformat
    ../Bsp/encoder/: abs_enc.c hall_enc.c inc_enc.c abs_tformat.c absEnc.c
    ../Bsp/: adconv.c pwmctrl.c
  group libraries/freemodbus/core
    ../Libraries/freemodbus/: mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbtcp.c mbutils.c
  group libraries/freemodbus/port
    ../Libraries/freemodbus/: portcb.c portevent.c portserial.c porttimer.c bsp_uart.c
  group database
    ../Database/: paraattr.c paratbl.h paraattr.h
  group components/motspin
    ../Bsp/: motdrv.c
  group DSP
    ../../../platform/stm32g0_hal/fwlib/STM32Cube_FW_G0_V1.6.0/Drivers/CMSIS/DSP/Source/ControllerFunctions/: arm_pid_init_q15.c arm_pid_reset_q15.c arm_pid_init_q31.c arm_pid_reset_q31.c
  group axis/motdrv
    ../Axis/motdrv/: motdrv.c posloop.c spdloop.c curloop.c cursamp.c motpos.c motspd.c
  group axis/pathplan
    ../Axis/pathplan/: pathplan.c posplan.c spdplan.c trqplan.c
  group axis/logicctrl
    ../Axis/logicctrl/: cmdctrl.c homing.c logicctrl.c posctrl.c spdctrl.c trqctrl.c
  group axis/application
    ../Axis/application/: appmgr.c encident.c openloop.c functest.c
  group axis
    ../Axis/: axis.c
software components: CMSIS:CORE 6.0.0
