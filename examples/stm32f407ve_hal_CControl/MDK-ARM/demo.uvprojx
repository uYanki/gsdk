# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,NON_UNIX_STDIO,IS_C89
  c misc: -Wno-shift-negative-value -Wno-shift-count-negative -Wno-int-to-void-pointer-cast -Wno-unused-value
  c include: ../Core/Inc;../../../kernel;../../../kernel/hwif;../../../platform/stm32f4_hal/boards/stm32f407ve_xws;../../../platform/stm32f4_hal/adapter;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Include;..\..\..\components\CControl;..\..\..\components\timestamp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c rng.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c syscall.c
  group Drivers/STM32F4xx_HAL_Driver
    E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group kernel/hwif
    ../../../kernel/hwif/: delay.c
  group kernel/base
    ../../../kernel/: gversion.c hexdump.c logger.c gstdio.c bitops.c
  group platform/adapter
    ../../../platform/stm32f4_hal/adapter/: arm_dwt.c drv_hwuart.c drv_pinctrl.c drv_timer.c
  group component/CControl/Hardware
    ../../../components/CControl/Hardware/: concatenate_paths.c count_sub_folders.c detectmemoryleak.c saveload.c scan_file_names.c scan_sub_folder_names.c
  group component/CControl/ArtificialIntelligence
    ../../../components/CControl/ArtificialIntelligence/: Astar.c inpolygon.c
  group component/CControl/ComputerVision
    ../../../components/CControl/ComputerVision/: cornerdetection.c featuredetection.c fisherfaces.c generalizedhough.c hough.c violajones.c
  group component/CControl/ControlEngineering
    ../../../components/CControl/ControlEngineering/: c2d.c cab.c obsv.c qmpc.c ssint.c stability.c
  group component/CControl/ImageProcessing
    ../../../components/CControl/ImageProcessing/: fspecial.c haarlike.c harris.c imcollect.c imfree.c imgaussfilt.c imread.c imresize.c imshow.c imwrite.c integralimage.c intensitycentroid.c lbp.c pooling.c rpca.c sobel.c
  group component/CControl/LinearAlgebra
    ../../../components/CControl/LinearAlgebra/: balance.c chol.c cholupdate.c conv.c conv2.c conv2fft.c convfft.c det.c dlyap.c dot.c eig.c eig_generalized.c expm.c hankel.c inv.c linsolve_chol.c linsolve_gauss.c linsolve_lower_triangular.c linsolve_lup.c linsolve_qr.c linsolve_upper_triangular.c lup.c mul.c nonlinsolve.c norm.c pinv.c qr.c rank.c svd.c tran.c
  group component/CControl/LinearAlgebra/CLapack/Routines
    ../../../components/CControl/LinearAlgebra/CLapack/Routines/: ieeeck.c iladlc.c iladlr.c ilaenv.c ilaslc.c ilaslr.c iparmq.c isamax.c lsame.c saxpy.c sbdsdc.c sbdsqr.c sceil.c scopy.c sdot.c sgebak.c sgebal.c sgebd2.c sgebrd.c sgeev.c sgehd2.c sgehrd.c sgelq2.c sgelqf.c sgemm.c sgemv.c sgeqr2.c sgeqrf.c sger.c sgesdd.c sgesvd.c sgetrf.c sgetri.c sgetrs.c sggbak.c sggbal.c sggev.c sgghrd.c shgeqz.c shseqr.c sisnan.c slabad.c slabrd.c slacpy.c sladiv.c slae2.c slaed0.c slaed1.c slaed2.c slaed3.c slaed4.c slaed5.c slaed6.c slaed7.c slaed8.c slaed9.c slaeda.c slaev2.c slaexc.c slag2.c slahqr.c slahr2.c slaisnan.c slaln2.c slamch.c slamrg.c slange.c slanhs.c slanst.c slansy.c slanv2.c slapy2.c slapy3.c slaqr0.c slaqr1.c slaqr2.c slaqr3.c slaqr4.c slaqr5.c slarf.c slarfb.c slarfg.c slarfp.c slarft.c slarfx.c slartg.c slas2.c slascl.c slasd0.c slasd1.c slasd2.c slasd3.c slasd4.c slasd5.c slasd6.c slasd7.c slasd8.c slasda.c slasdq.c slasdt.c slaset.c slasq1.c slasq2.c slasq3.c slasq4.c slasq5.c slasq6.c slasr.c slasrt.c slassq.c slasv2.c slaswp.c slasy2.c slatrd.c snrm2.c sorg2r.c sorgbr.c sorghr.c sorgl2.c sorglq.c sorgqr.c sorm2l.c sorm2r.c sormbr.c sormhr.c sorml2.c sormlq.c sormql.c sormqr.c sormtr.c sposv.c spotf2.c spotrf.c spotrs.c srot.c sscal.c sstedc.c ssteqr.c ssterf.c sswap.c ssyevd.c ssygs2.c ssygst.c ssygvd.c ssymm.c ssymv.c ssyr2.c ssyr2k.c ssyrk.c ssytd2.c ssytrd.c stgevc.c strevc.c strexc.c strmm.c strmv.c strsm.c strsv.c strti2.c strtri.c xerbla.c
  group component/CControl/LinearAlgebra/CLapack/Tools
    ../../../components/CControl/LinearAlgebra/CLapack/Tools/: close.c endfile.c err.c exit_.c f77_aloc.c fmt.c fmtlib.c i_len_trim.c i_nint.c open.c pow_dd.c pow_ii.c pow_ri.c r_lg10.c r_sign.c s_cat.c s_cmp.c s_copy.c s_stop.c sfe.c sig_die.c util.c wref.c wrtfmt.c wsfe.c
  group component/CControl/MachineLearning
    ../../../components/CControl/MachineLearning/: adaboost.c dbscan.c kernel.c kmeans.c kpca.c kpca_lda_nn.c nn.c svm.c
  group component/CControl/Miscellaneous
    ../../../components/CControl/Miscellaneous/: anglevector.c cat.c cumsum.c cut.c deg2rad.c find.c float2uint.c ind2sub.c insert.c issymmetric.c normalize.c pdist2.c popcount.c print.c rad2deg.c radianvector.c rot2d.c saturation.c scalar.c shuffle.c sign.c sort.c sum.c uint2float.c unique.c unit.c vmax.c vmin.c
  group component/CControl/Optimization
    ../../../components/CControl/Optimization/: linprog.c lsqnonneg.c quadprog.c
  group component/CControl/SignalProcessing
    ../../../components/CControl/SignalProcessing/: clusterfilter.c fft.c fft2.c fftshift.c filtfilt.c ifft.c ifft2.c ifftshift.c pf.c sr_ukf_state_estimation.c
    ../../../components/CControl/SignalProcessing/FFTpack/: fftpack.c
  group component/CControl/Statistics
    ../../../components/CControl/Statistics/: amax.c amin.c area.c center.c centroid.c clusterratio.c clustersdistance.c cov.c covm.c giniimpurity.c lda.c mean.c normpdf.c opa.c pca.c randi.c randn.c randperm.c stddev.c var.c
  group component/CControl/SystemIdentification
    ../../../components/CControl/SystemIdentification/: era.c okid.c rls.c sr_ukf_parameter_estimation.c theta2ss.c
  group Example/CControl
    ../../../components/CControl/Examples/ControlEngineering/: obsv_test.c
    ../../../components/CControl/Examples/SignalProcessing/: fft_test.c
  group component/timestamp
    ../../../components/timestamp/: timestamp.c
software components: CMSIS:CORE 6.0.0
