# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,UKAL_MAX_STATE_VECTOR_SIZE=5,UKAL_MAX_MEASUREMENT_VECTOR_SIZE=5,ULAPACK_MATRIX_ENTRY_TYPE=double,ULAPACK_INDEX_TYPE=uint64_t,ULAPACK_SIGNED_INDEX_TYPE=int64_t,ULAPACK_USE_STATIC_ALLOC=1,ULAPACK_MAX_MATRIX_N_ROWS=5,ULAPACK_MAX_MATRIX_N_COLS=5,ULAPACK_INITIALIZE_MEMORY=1,ULAPACK_INVERSE_VIA_LU=1,ULAPACK_MINIMUM_THRESHOLD_TOLERANCE=.0001
  c include: ../Core/Inc;../../../kernel;../../../kernel/hwif;../../../platform/stm32f4_hal/boards/stm32f407ve_xws;../../../platform/stm32f4_hal/adapter;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/CMSIS/Include;..\..\..\components\uLAPack;..\..\..\components\uKal
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    E:/gsdk/platform/stm32f4_hal/fwlib/STM32Cube_FW_F4_V1.28.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group kernel/hwif
    ../../../kernel/hwif/: delay.c
  group kernel/base
    ../../../kernel/: gversion.c hexdump.c logger.c gstdio.c bitops.c
  group platform/adapter
    ../../../platform/stm32f4_hal/adapter/: arm_dwt.c drv_hwuart.c drv_pinctrl.c drv_timer.c syscall.c
  group component/uKal
    ../../../components/uKal/: ukal.c ukal_test.c
  group component/uLAPack
    ../../../components/uLAPack/: ulapack.c ulapack_test.c
software components: CMSIS:CORE 5.5.0
