# Keil uVision project demo.uvprojx, settings and files
target demo (6160000::V6.16::ARMCLANG)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.4
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER
  c include: ../Core/Inc;../../../kernel;../../../kernel/hwif;../../../components/device;../../../components/flexbtn;../../../platform/at32f415_std/boards/at32f415cb_dev;../../../platform/at32f415_std/adapter;../../../components/eefs;../../../components/CmBacktrace;../../../components/SEGGER_RTT;../../../platform/at32f415_std/fwlib/drivers/inc;../../../platform/at32f415_std/fwlib/cmsis/cm4/core_support;../../../platform/at32f415_std/fwlib/cmsis/cm4/device_support;..\Middlewares\USB;..\Middlewares\USB\usb_drivers\inc;..\Middlewares\USB\usbd_class\mouse
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/User/Core
    ../Core/Src/: at32f415_clock.c at32f415_int.c main.c
  group Drivers/AT2F1xx_STD_Driver
    ../../../platform/at32f415_std/fwlib/drivers/src/: at32f415_adc.c at32f415_can.c at32f415_cmp.c at32f415_crc.c at32f415_crm.c at32f415_debug.c at32f415_dma.c at32f415_ertc.c at32f415_exint.c at32f415_flash.c at32f415_gpio.c at32f415_i2c.c at32f415_misc.c at32f415_pwc.c at32f415_sdio.c at32f415_spi.c at32f415_tmr.c at32f415_usart.c at32f415_usb.c at32f415_wdt.c at32f415_wwdt.c
  group Drivers/CMSIS
    ../Core/Src/: system_at32f415.c
  group Application/MDK-ARM
    ../Core/Src/: startup_at32f415.s
  group kernel/hwif
    ../../../kernel/hwif/: delay.c pinctrl.c i2cmst.c spimst.c swi2cmst.c swspimst.c
  group kernel/base
    ../../../kernel/: gversion.c hexdump.c logger.c gstdio.c bitops.c
  group platform/adapter
    ../../../platform/at32f415_std/adapter/: i2c_application.c arm_dwt.c drv_hwi2cmst.c drv_hwspimst.c drv_hwuart.c drv_pinctrl.c drv_timer.c syscall.c
  group components/segger-rtt
    ../../../components/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group components/cmbacktrace
    ../../../components/CmBacktrace/: cm_backtrace.c cmb_fault_keil.S
  group middleware/usbd
    ../Middlewares/USB/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
    ../Middlewares/USB/usbd_class/mouse/: mouse_class.c mouse_desc.c
